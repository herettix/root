# Keil uVision project proj3.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C31 NXP (founded by Philips)
  cpu: IRAM(0-0x7F) CLOCK(33000000)
  output: proj3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: zad4.c
  group Zadatak 6
    ./: termo.c
  group Zadatak 10
    ./: sat.c
